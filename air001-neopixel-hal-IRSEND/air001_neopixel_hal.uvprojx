# Keil uVision project air001_neopixel_hal.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.2
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: air001_neopixel_hal +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,AIR001_DEV
  c include: .\AIR001xx_HAL_Driver\Inc;.\APP;.\NeoPixel
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ./APP/: air001xx_it.c main.c infrared.c delay.c gpio.c dma.c effects.c spi.c ws2812.c air001xx_hal_msp.c
  group HAL
    ./AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_adc.c air001xx_hal_adc_ex.c air001xx_hal_cortex.c air001xx_hal_flash.c air001xx_hal_gpio.c air001xx_hal_pwr.c air001xx_hal_pwr_ex.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_dma.c air001xx_hal_spi.c air001xx_hal_uart.c
  group NeoPixel
    ./NeoPixel/: Adafruit_NeoPixel.c
software components: CMSIS:CORE 6.0.0, Device:Startup 0.0.1
